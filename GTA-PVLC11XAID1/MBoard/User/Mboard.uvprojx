# Keil uVision project Mboard.uvprojx, settings and files
target MBoard (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mboard +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --locale=english
  c include: ..\..\MBoard;..\User;.\UsrF;..\Module;..\Module\Actuator;..\Module\DATS;..\Module\KEY&TIPS;..\Module\LCD;..\Module\Sensor_Analog;..\Module\Sensor_Digital;..\Module\Transmitter_USART
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ./UsrF/: Main.c Bsp.c stm32f10x_it.c SVC_Table.s
  group Module
    ../Module/Transmitter_USART/: WirelessTrans_USART.c
    ../Module/KEY&TIPS/: Key&Tips.c
    ../Module/: carOp.c
  group 系统驱动改写
    ./UsrF/: USART_STM32F10x.c
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX 4.81.1, CMSIS Driver:CAN 1.6, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
